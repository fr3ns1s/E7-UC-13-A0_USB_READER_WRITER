# Keil uVision project Reader.uvprojx, settings and files
target GD32F10X_HD (6180000::V6.18::ARMCLANG)
  device: GD32F103VC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.3
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_STDPERIPH_DRIVER,GD32F10X_HD
  c include: .\include;.\lib\RFID\include;.\lib\LCD\include;.\lib\KEYBOARD\include;.\lib\EEPROM\include;.\Firmware\CMSIS;.\Firmware\CMSIS\GD\GD32F10x\Include;.\Firmware\GD32F10x_standard_peripheral\Include;.\Firmware\GD32F10x_usbd_library\usbd\Include;.\Firmware\GD32F10x_usbd_library\device\Include;.\Firmware\GD32F10x_usbd_library\class\device\cdc\Include;..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application
    ./src/: gd32f10x_it.c main.c
    ./include/: board_conf.h main.h
  group USBD_Drivers
    ./Firmware/GD32F10x_usbd_library/usbd/Source/: usbd_lld_core.c usbd_lld_int.c
  group USBD_Device
    ./Firmware/GD32F10x_usbd_library/device/Source/: usbd_core.c usbd_enum.c usbd_pwr.c usbd_transc.c
  group USBD_Class
    ./Firmware/GD32F10x_usbd_library/class/device/cdc/Source/: cdc_acm_core.c
  group CMSIS
    ./Firmware/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
  group Peripherals
    ./Firmware/GD32F10x_standard_peripheral/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group Startup
    ./Firmware/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_hd.s
  group LCD
    ./lib/LCD/include/: lcd.h
    ./lib/LCD/src/: lcd.c
  group KEYBOARD
    ./lib/KEYBOARD/include/: keyboard.h
    ./lib/KEYBOARD/src/: keyboard.c
  group RFID
    ./lib/RFID/include/: fm1702.h spi_fm1702.h
    ./lib/RFID/src/: fm1702.c spi_fm1702.c
  group EEPROM
    ./lib/EEPROM/include/: at24cxx.h
    ./lib/EEPROM/src/: at24cxx.c
  group USB_CONF
    ./src/: gd32f10x_usbd_hw.c
    ../Reader/include/: usbd_hw.h usb_conf.h usbd_conf.h
  group UTILS
    ./src/: systick.c
    ../Reader/include/: systick.h
